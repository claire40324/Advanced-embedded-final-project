# Keil uVision project p3.uvproj, settings and files
target Target_1 (5060960::V5.06 update 7 (build 960)::.\ARMCompiler_5.06u7)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: p3
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: FIFO.c FIFO.h joystick.c joystick.h LCD.c LCD.h Main.c os.c os.h PLL.c PLL.h PORTE.c PORTE.h README.md startup.s tm4c123gh6pm.h UART.c UART.h UART_FIFO.c UART_FIFO.h osasm.s sound.c sound.h
